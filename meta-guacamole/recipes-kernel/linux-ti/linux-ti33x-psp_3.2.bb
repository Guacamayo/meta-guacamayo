SECTION = "kernel"
DESCRIPTION = "Linux kernel for TI33x EVM from PSP, based on am335x-kernel"
LICENSE = "GPLv2"
KERNEL_IMAGETYPE = "uImage"

require multi-kernel.inc
require tipspkernel.inc

S = "${WORKDIR}/git"

MULTI_CONFIG_BASE_SUFFIX = ""

BRANCH = "v3.2-staging"
SRCREV = "e8004dad869568692ca2a45c04e8464ce48cc4d7"
MACHINE_KERNEL_PR_append = "d+gitr${SRCREV}"

COMPATIBLE_MACHINE = "(ti33x)"

SRC_URI += "git://arago-project.org/git/projects/linux-am33x.git;protocol=http;branch=${BRANCH} \
	file://am335x-pm-firmware.bin \
	file://defconfig"

SRC_URI_append_beaglebone = " file://logo_linux_clut224.ppm"

do_compile_prepend() {
	cp ${WORKDIR}/am335x-pm-firmware.bin ${S}/firmware/
}

PATCHES_OVER_PSP = " \
	file://3.2.1/0001-MAINTAINERS-stable-Update-address.patch \
	file://3.2.1/0002-Documentation-Update-stable-address.patch \
	file://3.2.1/0003-firmware-Fix-an-oops-on-reading-fw_priv-fw-in-sysfs-.patch \
	file://3.2.1/0004-rt2800usb-Move-ID-out-of-unknown.patch \
	file://3.2.1/0005-offb-Fix-setting-of-the-pseudo-palette-for-8bpp.patch \
	file://3.2.1/0006-offb-Fix-bug-in-calculating-requested-vram-size.patch \
	file://3.2.1/0007-libertas-clean-up-scan-thread-handling.patch \
	file://3.2.1/0008-bcma-support-for-suspend-and-resume.patch \
	file://3.2.1/0009-wl12xx-Validate-FEM-index-from-ini-file-and-FW.patch \
	file://3.2.1/0010-wl12xx-Check-buffer-bound-when-processing-nvs-data.patch \
	file://3.2.1/0011-wl12xx-Restore-testmode-ABI.patch \
	file://3.2.1/0012-powerpc-time-Handle-wrapping-of-decrementer.patch \
	file://3.2.1/0013-powerpc-Fix-unpaired-probe_hcall_entry-and-probe_hca.patch \
	file://3.2.1/0014-IB-qib-Fix-a-possible-data-corruption-when-receiving.patch \
	file://3.2.1/0015-IB-uverbs-Protect-QP-multicast-list.patch \
	file://3.2.1/0016-iwlagn-fix-TID-use-bug.patch \
	file://3.2.1/0017-iwlagn-fix-remove-use-of-PAGE_SIZE.patch \
	file://3.2.1/0018-perf-Fix-parsing-of-__print_flags-in-TP_printk.patch \
	file://3.2.1/0019-ore-Fix-crash-in-case-of-an-IO-error.patch \
	file://3.2.1/0020-ore-fix-BUG_ON-too-few-sgs-when-reading.patch \
	file://3.2.1/0021-ore-Must-support-none-PAGE-aligned-IO.patch \
	file://3.2.1/0022-ore-FIX-breakage-when-MISC_FILESYSTEMS-is-not-set.patch \
	file://3.2.1/0023-reiserfs-Fix-quota-mount-option-parsing.patch \
	file://3.2.1/0024-reiserfs-Force-inode-evictions-before-umount-to-avoi.patch \
	file://3.2.1/0025-ext3-Don-t-warn-from-writepage-when-readonly-inode-i.patch \
	file://3.2.1/0026-drivers-hv-Don-t-OOPS-when-you-cannot-init-vmbus.patch \
	file://3.2.1/0027-Drivers-hv-Fix-a-bug-in-vmbus_driver_unregister.patch \
	file://3.2.1/0028-USB-update-documentation-for-usbmon.patch \
	file://3.2.1/0029-usbfs-Fix-oops-related-to-user-namespace-conversion.patch \
	file://3.2.1/0030-atmel_serial-fix-spinlock-lockup-in-RS485-code.patch \
	file://3.2.1/0031-cgroup-fix-to-allow-mounting-a-hierarchy-by-name.patch \
	file://3.2.1/0032-udf-Fix-deadlock-when-converting-file-from-in-ICB-on.patch \
	file://3.2.1/0033-drivers-usb-class-cdc-acm.c-clear-dangling-pointer.patch \
	file://3.2.1/0034-USB-isight-fix-kernel-bug-when-loading-firmware.patch \
	file://3.2.1/0035-usb-usb-storage-doesn-t-support-dynamic-id-currently.patch \
	file://3.2.1/0036-USB-pxa168-Fix-compilation-error.patch \
	file://3.2.1/0037-USB-add-quirk-for-another-camera.patch \
	file://3.2.1/0038-USB-omninet-fix-write_room.patch \
	file://3.2.1/0039-usb-option-add-ZD-Incorporated-HSPA-modem.patch \
	file://3.2.1/0040-USB-Add-USB-ID-for-Multiplex-RC-serial-adapter-to-cp.patch \
	file://3.2.1/0041-usb-fix-number-of-mapped-SG-DMA-entries.patch \
	file://3.2.1/0042-xhci-Properly-handle-COMP_2ND_BW_ERR.patch \
	file://3.2.1/0043-usb-ch9-fix-up-MaxStreams-helper.patch \
	file://3.2.1/0044-igmp-Avoid-zero-delay-when-receiving-odd-mixture-of-.patch \
	file://3.2.1/0045-asix-fix-infinite-loop-in-rx_fixup.patch \
	file://3.2.1/0046-bonding-fix-error-handling-if-slave-is-busy-v2.patch \
	file://3.2.1/0047-usb-cdc-acm-Fix-acm_tty_hangup-vs.-acm_tty_close-rac.patch \
	file://3.2.1/0048-xfs-fix-acl-count-validation-in-xfs_acl_from_disk.patch \
	file://3.2.1/0049-Linux-3.2.1.patch \
	file://3.2.2/0001-mtdoops-fix-the-oops_page_used-array-size.patch \
	file://3.2.2/0002-mtd-mtdoops-skip-reading-initially-bad-blocks.patch \
	file://3.2.2/0003-mtd-mtd_blkdevs-don-t-increase-open-count-on-error-p.patch \
	file://3.2.2/0004-mtd-tests-stresstest-bail-out-if-device-has-not-enou.patch \
	file://3.2.2/0005-drivers-rtc-interface.c-fix-alarm-rollover-when-day-.patch \
	file://3.2.2/0006-ext4-add-missing-ext4_resize_end-on-error-paths.patch \
	file://3.2.2/0007-ext4-fix-undefined-behavior-in-ext4_fill_flex_info.patch \
	file://3.2.2/0008-ALSA-snd-usb-us122l-Delete-calls-to-preempt_disable.patch \
	file://3.2.2/0009-ALSA-HDA-Fix-master-control-for-Cirrus-Logic-421X.patch \
	file://3.2.2/0010-ALSA-HDA-Fix-automute-for-Cirrus-Logic-421x.patch \
	file://3.2.2/0011-ALSA-ice1724-Check-for-ac97-to-avoid-kernel-oops.patch \
	file://3.2.2/0012-ALSA-usb-audio-Avoid-flood-of-frame-active-debug-mes.patch \
	file://3.2.2/0013-ALSA-hda-Use-auto-parser-for-HP-laptops-with-cx20459.patch \
	file://3.2.2/0014-ALSA-hda-Return-the-error-from-get_wcaps_type-for-in.patch \
	file://3.2.2/0015-ALSA-hda-Fix-the-detection-of-Loopback-Mixing-contro.patch \
	file://3.2.2/0016-ALSA-hda-Fix-the-lost-power-setup-of-seconary-pins-a.patch \
	file://3.2.2/0017-drm-radeon-kms-workaround-invalid-AVI-infoframe-chec.patch \
	file://3.2.2/0018-drm-radeon-kms-disable-writeback-on-pre-R300-asics.patch \
	file://3.2.2/0019-radeon-Fix-disabling-PCI-bus-mastering-on-big-endian.patch \
	file://3.2.2/0020-pnfs-obj-pNFS-errors-are-communicated-on-iodata-pnfs.patch \
	file://3.2.2/0021-pnfs-obj-Must-return-layout-on-IO-error.patch \
	file://3.2.2/0022-NFS-Retry-mounting-NFSROOT.patch \
	file://3.2.2/0023-NFSv4.1-fix-backchannel-slotid-off-by-one-bug.patch \
	file://3.2.2/0024-NFS-fix-recent-breakage-to-NFS-error-handling.patch \
	file://3.2.2/0025-NFSv4-include-bitmap-in-nfsv4-get-acl-data.patch \
	file://3.2.2/0026-nfs-fix-regression-in-handling-of-context-option-in-.patch \
	file://3.2.2/0027-HID-bump-maximum-global-item-tag-report-size-to-96-b.patch \
	file://3.2.2/0028-HID-wiimote-Select-INPUT_FF_MEMLESS.patch \
	file://3.2.2/0029-UBI-fix-missing-scrub-when-there-is-a-bit-flip.patch \
	file://3.2.2/0030-UBI-fix-use-after-free-on-error-path.patch \
	file://3.2.2/0031-PCI-Fix-PCI_EXP_TYPE_RC_EC-value.patch \
	file://3.2.2/0032-PCI-msi-Disable-msi-interrupts-when-we-initialize-a-.patch \
	file://3.2.2/0033-x86-PCI-Ignore-CPU-non-addressable-_CRS-reserved-mem.patch \
	file://3.2.2/0034-x86-PCI-amd-factor-out-MMCONFIG-discovery.patch \
	file://3.2.2/0035-x86-PCI-build-amd_bus.o-only-when-CONFIG_AMD_NB-y.patch \
	file://3.2.2/0036-SCSI-mpt2sas-Release-spinlock-for-the-raid-device-li.patch \
	file://3.2.2/0037-SCSI-mpt2sas-Fix-for-memory-allocation-error-for-lar.patch \
	file://3.2.2/0038-xen-xenbus-Reject-replies-with-payload-XENSTORE_PAYL.patch \
	file://3.2.2/0039-md-raid1-perform-bad-block-tests-for-WriteMostly-dev.patch \
	file://3.2.2/0040-ima-free-duplicate-measurement-memory.patch \
	file://3.2.2/0041-ima-fix-invalid-memory-reference.patch \
	file://3.2.2/0042-slub-fix-a-possible-memleak-in-__slab_alloc.patch \
	file://3.2.2/0043-PNP-work-around-Dell-1536-1546-BIOS-MMCONFIG-bug-tha.patch \
	file://3.2.2/0044-asix-fix-setting-custom-MAC-address-on-Asix-88178-de.patch \
	file://3.2.2/0045-asix-fix-setting-custom-MAC-address-on-Asix-88772-de.patch \
	file://3.2.2/0046-include-linux-crash_dump.h-needs-elf.h.patch \
	file://3.2.2/0047-rtl8192se-Fix-BUG-caused-by-failure-to-check-skb-all.patch \
	file://3.2.2/0048-mac80211-fix-rx-key-NULL-pointer-dereference-in-prom.patch \
	file://3.2.2/0049-ath9k-Fix-regression-in-channelwidth-switch-at-the-s.patch \
	file://3.2.2/0050-memcg-add-mem_cgroup_replace_page_cache-to-fix-LRU-i.patch \
	file://3.2.2/0051-x86-Fix-mmap-random-address-range.patch \
	file://3.2.2/0052-UBI-fix-nameless-volumes-handling.patch \
	file://3.2.2/0053-UBI-fix-debugging-messages.patch \
	file://3.2.2/0054-UBI-make-vid_hdr-non-static.patch \
	file://3.2.2/0055-UBIFS-fix-debugging-messages.patch \
	file://3.2.2/0056-UBIFS-make-debugging-messages-light-again.patch \
	file://3.2.2/0057-i2c-Fix-error-value-returned-by-several-bus-drivers.patch \
	file://3.2.2/0058-mmc-core-Fix-voltage-select-in-DDR-mode.patch \
	file://3.2.2/0059-mmc-sdhci-Fix-tuning-timer-incorrect-setting-when-su.patch \
	file://3.2.2/0060-mmc-sd-Fix-SDR12-timing-regression.patch \
	file://3.2.2/0061-V4L-DVB-v4l2-ioctl-integer-overflow-in-video_usercop.patch \
	file://3.2.2/0062-Unused-iocbs-in-a-batch-should-not-be-accounted-as-a.patch \
	file://3.2.2/0063-ftrace-Fix-unregister-ftrace_ops-accounting.patch \
	file://3.2.2/0064-kconfig-streamline-config.pl-Simplify-backslash-line.patch \
	file://3.2.2/0065-kconfig-streamline-config.pl-Fix-parsing-Makefile-wi.patch \
	file://3.2.2/0066-svcrpc-fix-double-free-on-shutdown-of-nfsd-after-cha.patch \
	file://3.2.2/0067-svcrpc-destroy-server-sockets-all-at-once.patch \
	file://3.2.2/0068-svcrpc-avoid-memory-corruption-on-pool-shutdown.patch \
	file://3.2.2/0069-nfsd4-fix-lockowner-matching.patch \
	file://3.2.2/0070-nfsd-Fix-oops-when-parsing-a-0-length-export.patch \
	file://3.2.2/0071-fsnotify-don-t-BUG-in-fsnotify_destroy_mark.patch \
	file://3.2.2/0072-x86-UV-Update-Boot-messages-for-SGI-UV2-platform.patch \
	file://3.2.2/0073-recordmcount-Fix-handling-of-elf64-big-endian-object.patch \
	file://3.2.2/0074-uvcvideo-Fix-integer-overflow-in-uvc_ioctl_ctrl_map.patch \
	file://3.2.2/0075-dcache-use-a-dispose-list-in-select_parent.patch \
	file://3.2.2/0076-fix-shrink_dcache_parent-livelock.patch \
	file://3.2.2/0077-pnfsblock-acquire-im_lock-in-_preload_range.patch \
	file://3.2.2/0078-pnfsblock-don-t-spinlock-when-freeing-block_dev.patch \
	file://3.2.2/0079-pnfsblock-limit-bio-page-count.patch \
	file://3.2.2/0080-mac80211-revert-on-channel-work-optimisations.patch \
	file://3.2.2/0081-HID-hid-multitouch-add-another-eGalax-id.patch \
	file://3.2.2/0082-HID-multitouch-cleanup-with-eGalax-PID-definitions.patch \
	file://3.2.2/0083-HID-multitouch-Add-egalax-ID-for-Acer-Iconia-W500.patch \
	file://3.2.2/0084-HID-multitouch-add-support-for-the-MSI-Windpad-110W.patch \
	file://3.2.2/0085-HID-hid-multitouch-add-support-for-new-Hanvon-panels.patch \
	file://3.2.2/0086-HID-multitouch-add-support-of-Atmel-multitouch-panel.patch \
	file://3.2.2/0087-HID-multitouch-add-support-for-3M-32.patch \
	file://3.2.2/0088-HID-hid-multitouch-add-support-9-new-Xiroku-devices.patch \
	file://3.2.2/0089-fix-cputime-overflow-in-uptime_proc_show.patch \
	file://3.2.2/0090-block-add-and-use-scsi_blk_cmd_ioctl.patch \
	file://3.2.2/0091-block-fail-SCSI-passthrough-ioctls-on-partition-devi.patch \
	file://3.2.2/0092-dm-do-not-forward-ioctls-from-logical-volumes-to-the.patch \
	file://3.2.2/0093-proc-clean-up-and-fix-proc-pid-mem-handling.patch \
	file://3.2.2/0094-ALSA-HDA-Use-LPIB-position-fix-for-Macbook-Pro-7-1.patch \
	file://3.2.2/0095-ALSA-virtuoso-Xonar-DS-fix-polarity-of-front-output.patch \
	file://3.2.2/0096-ALSA-HDA-Fix-internal-microphone-on-Dell-Studio-16-X.patch \
	file://3.2.2/0097-TOMOYO-Accept-000-as-a-valid-character.patch \
	file://3.2.2/0098-intel-idle-Make-idle-driver-more-robust.patch \
	file://3.2.2/0099-intel_idle-fix-API-misuse.patch \
	file://3.2.2/0100-ACPI-Store-SRAT-table-revision.patch \
	file://3.2.2/0101-ACPI-x86-Use-SRAT-table-rev-to-use-8bit-or-32bit-PXM.patch \
	file://3.2.2/0102-ACPI-ia64-Use-SRAT-table-rev-to-use-8bit-or-16-32bit.patch \
	file://3.2.2/0103-ACPICA-Put-back-the-call-to-acpi_os_validate_address.patch \
	file://3.2.2/0104-ACPI-processor-fix-acpi_get_cpuid-for-UP-processor.patch \
	file://3.2.2/0105-sym53c8xx-Fix-NULL-pointer-dereference-in-slave_dest.patch \
	file://3.2.2/0106-target-Set-response-format-in-INQUIRY-response.patch \
	file://3.2.2/0107-target-Set-additional-sense-length-field-in-sense-da.patch \
	file://3.2.2/0108-bcma-invalidate-the-mapped-core-over-suspend-resume.patch \
	file://3.2.2/0109-cx23885-dvb-check-if-dvb_attach-succeded.patch \
	file://3.2.2/0110-cx88-fix-don-t-duplicate-xc4000-entry-for-radio.patch \
	file://3.2.2/0111-tuner-Fix-numberspace-conflict-between-xc4000-and-pt.patch \
	file://3.2.2/0112-tracepoints-module-Fix-disabling-tracepoints-with-ta.patch \
	file://3.2.2/0113-x86-UV2-Fix-new-UV2-hardware-by-using-native-UV2-bro.patch \
	file://3.2.2/0114-x86-UV2-Fix-BAU-destination-timeout-initialization.patch \
	file://3.2.2/0115-x86-UV2-Work-around-BAU-bug.patch \
	file://3.2.2/0116-ath9k_hw-fix-interpretation-of-the-rx-KeyMiss-flag.patch \
	file://3.2.2/0117-rt2800pci-fix-spurious-interrupts-generation.patch \
	file://3.2.2/0118-xfs-fix-endian-conversion-issue-in-discard-code.patch \
	file://3.2.2/0119-i2c-eg20t-modified-the-setting-of-transfer-rate.patch \
	file://3.2.2/0120-score-fix-off-by-one-index-into-syscall-table.patch \
	file://3.2.2/0121-cifs-lower-default-wsize-when-unix-extensions-are-no.patch \
	file://3.2.2/0122-kprobes-initialize-before-using-a-hlist.patch \
	file://3.2.2/0123-proc-clear_refs-do-not-clear-reserved-pages.patch \
	file://3.2.2/0124-mm-fix-NULL-ptr-dereference-in-__count_immobile_page.patch \
	file://3.2.2/0125-iwlagn-check-for-SMPS-mode.patch \
	file://3.2.2/0126-iwlegacy-3945-fix-hw-passive-scan-on-radar-channels.patch \
	file://3.2.2/0127-SHM_UNLOCK-fix-long-unpreemptible-section.patch \
	file://3.2.2/0128-SHM_UNLOCK-fix-Unevictable-pages-stranded-after-swap.patch \
	file://3.2.2/0129-Linux-3.2.2.patch \
	file://3.2.3/0001-ALSA-hda-Fix-buffer-alignment-regression-with-Nvidia.patch \
	file://3.2.3/0002-ALSA-hda-Fix-silent-outputs-from-docking-station-jac.patch \
	file://3.2.3/0003-eCryptfs-Sanitize-write-counts-of-dev-ecryptfs.patch \
	file://3.2.3/0004-ecryptfs-Improve-metadata-read-failure-logging.patch \
	file://3.2.3/0005-eCryptfs-Make-truncate-path-killable.patch \
	file://3.2.3/0006-eCryptfs-Check-inode-changes-in-setattr.patch \
	file://3.2.3/0007-eCryptfs-Fix-oops-when-printing-debug-info-in-extent.patch \
	file://3.2.3/0008-drm-radeon-kms-Add-an-MSI-quirk-for-Dell-RS690.patch \
	file://3.2.3/0009-drm-radeon-kms-move-panel-mode-setup-into-encoder-mo.patch \
	file://3.2.3/0010-drm-radeon-kms-rework-modeset-sequence-for-DCE41-and.patch \
	file://3.2.3/0011-drm-Fix-authentication-kernel-crash.patch \
	file://3.2.3/0012-xfs-Fix-missing-xfs_iunlock-on-error-recovery-path-i.patch \
	file://3.2.3/0013-ASoC-Mark-WM5100-register-map-cache-only-when-going-.patch \
	file://3.2.3/0014-ASoC-Disable-register-synchronisation-for-low-freque.patch \
	file://3.2.3/0015-ASoC-Don-t-go-through-cache-when-applying-WM5100-rev.patch \
	file://3.2.3/0016-ASoC-wm8996-Call-_POST_PMU-callback-for-CPVDD.patch \
	file://3.2.3/0017-brcmsmac-fix-tx-queue-flush-infinite-loop.patch \
	file://3.2.3/0018-mac80211-fix-work-removal-on-deauth-request.patch \
	file://3.2.3/0019-jbd-Issue-cache-flush-after-checkpointing.patch \
	file://3.2.3/0020-crypto-sha512-make-it-work-undo-percpu-message-sched.patch \
	file://3.2.3/0021-crypto-sha512-reduce-stack-usage-to-safe-number.patch \
	file://3.2.3/0022-tpm_tis-add-delay-after-aborting-command.patch \
	file://3.2.3/0023-x86-uv-Fix-uninitialized-spinlocks.patch \
	file://3.2.3/0024-x86-uv-Fix-uv_gpa_to_soc_phys_ram-shift.patch \
	file://3.2.3/0025-x86-microcode_amd-Add-support-for-CPU-family-specifi.patch \
	file://3.2.3/0026-m68k-Fix-assembler-constraint-to-prevent-overeager-g.patch \
	file://3.2.3/0027-ALSA-hda-set-mute-led-polarity-for-laptops-with-bugg.patch \
	file://3.2.3/0028-ALSA-hda-Fix-silent-output-on-ASUS-A6Rp.patch \
	file://3.2.3/0029-ALSA-hda-Fix-silent-output-on-Haier-W18-laptop.patch \
	file://3.2.3/0030-drm-i915-paper-over-missed-irq-issues-with-force-wak.patch \
	file://3.2.3/0031-drm-i915-sdvo-always-set-positive-sync-polarity.patch \
	file://3.2.3/0032-drm-i915-Re-enable-gen7-RC6-and-GPU-turbo-after-resu.patch \
	file://3.2.3/0033-ARM-at91-fix-at91rm9200-soc-subtype-handling.patch \
	file://3.2.3/0034-mach-ux500-enable-ARM-errata-764369.patch \
	file://3.2.3/0035-ARM-7296-1-proc-v7.S-remove-HARVARD_CACHE-preprocess.patch \
	file://3.2.3/0036-sysfs-Complain-bitterly-about-attempts-to-remove-fil.patch \
	file://3.2.3/0037-x86-xen-size-struct-xen_spinlock-to-always-fit-in-ar.patch \
	file://3.2.3/0038-mpt2sas-Removed-redundant-calling-of-_scsih_probe_de.patch \
	file://3.2.3/0039-USB-option-Add-LG-docomo-L-02C.patch \
	file://3.2.3/0040-USB-ftdi_sio-fix-TIOCSSERIAL-baud_base-handling.patch \
	file://3.2.3/0041-USB-ftdi_sio-fix-initial-baud-rate.patch \
	file://3.2.3/0042-USB-ftdi_sio-add-PID-for-TI-XDS100v2-BeagleBone-A3.patch \
	file://3.2.3/0043-USB-serial-ftdi-additional-IDs.patch \
	file://3.2.3/0044-USB-ftdi_sio-Add-more-identifiers.patch \
	file://3.2.3/0045-USB-cdc-wdm-updating-desc-length-must-be-protected-b.patch \
	file://3.2.3/0046-USB-cdc-wdm-use-two-mutexes-to-allow-simultaneous-re.patch \
	file://3.2.3/0047-qcaux-add-more-Pantech-UML190-and-UML290-ports.patch \
	file://3.2.3/0048-usb-dwc3-ep0-tidy-up-Pending-Request-handling.patch \
	file://3.2.3/0049-usb-io_ti-Make-edge_remove_sysfs_attrs-the-port_remo.patch \
	file://3.2.3/0050-TTY-fix-UV-serial-console-regression.patch \
	file://3.2.3/0051-serial-amba-pl011-lock-console-writes-against-interr.patch \
	file://3.2.3/0052-jsm-Fixed-EEH-recovery-error.patch \
	file://3.2.3/0053-iwlwifi-fix-PCI-E-transport-inta-race.patch \
	file://3.2.3/0054-vmwgfx-Fix-assignment-in-vmw_framebuffer_create_hand.patch \
	file://3.2.3/0055-USB-Realtek-cr-fix-autopm-scheduling-while-atomic.patch \
	file://3.2.3/0056-USB-usbsevseg-fix-max-length.patch \
	file://3.2.3/0057-usb-gadget-langwell-don-t-call-gadget-s-disconnect.patch \
	file://3.2.3/0058-usb-gadget-storage-endian-fix.patch \
	file://3.2.3/0059-drivers-usb-host-ehci-fsl.c-add-missing-iounmap.patch \
	file://3.2.3/0060-xhci-Fix-USB-3.0-device-restart-on-resume.patch \
	file://3.2.3/0061-xHCI-Cleanup-isoc-transfer-ring-when-TD-length-misma.patch \
	file://3.2.3/0062-usb-musb-davinci-fix-build-breakage.patch \
	file://3.2.3/0063-hwmon-f71805f-Fix-clamping-of-temperature-limits.patch \
	file://3.2.3/0064-hwmon-w83627ehf-Disable-setting-DC-mode-for-pwm2-pwm.patch \
	file://3.2.3/0065-hwmon-sht15-fix-bad-error-code.patch \
	file://3.2.3/0066-USB-cdc-wdm-call-wake_up_all-to-allow-driver-to-shut.patch \
	file://3.2.3/0067-USB-cdc-wdm-better-allocate-a-buffer-that-is-at-leas.patch \
	file://3.2.3/0068-USB-cdc-wdm-Avoid-hanging-on-interface-with-no-USB_C.patch \
	file://3.2.3/0069-netns-fix-net_alloc_generic.patch \
	file://3.2.3/0070-netns-Fail-conspicously-if-someone-uses-net_generic-.patch \
	file://3.2.3/0071-net-caif-Register-properly-as-a-pernet-subsystem.patch \
	file://3.2.3/0072-af_unix-fix-EPOLLET-regression-for-stream-sockets.patch \
	file://3.2.3/0073-bonding-fix-enslaving-in-alb-mode-when-link-down.patch \
	file://3.2.3/0074-l2tp-l2tp_ip-fix-possible-oops-on-packet-receive.patch \
	file://3.2.3/0075-macvlan-fix-a-possible-use-after-free.patch \
	file://3.2.3/0076-net-bpf_jit-fix-divide-by-0-generation.patch \
	file://3.2.3/0077-net-reintroduce-missing-rcu_assign_pointer-calls.patch \
	file://3.2.3/0078-rds-Make-rds_sock_lock-BH-rather-than-IRQ-safe.patch \
	file://3.2.3/0079-tcp-fix-tcp_trim_head-to-adjust-segment-count-with-s.patch \
	file://3.2.3/0080-tcp-md5-using-remote-adress-for-md5-lookup-in-rst-pa.patch \
	file://3.2.3/0081-USB-serial-CP210x-Added-USB-ID-for-the-Link-Instrume.patch \
	file://3.2.3/0082-USB-cp210x-call-generic-open-last-in-open.patch \
	file://3.2.3/0083-USB-cp210x-fix-CP2104-baudrate-usage.patch \
	file://3.2.3/0084-USB-cp210x-do-not-map-baud-rates-to-B0.patch \
	file://3.2.3/0085-USB-cp210x-fix-up-set_termios-variables.patch \
	file://3.2.3/0086-USB-cp210x-clean-up-refactor-and-document-speed-hand.patch \
	file://3.2.3/0087-USB-cp210x-initialise-baud-rate-at-open.patch \
	file://3.2.3/0088-USB-cp210x-allow-more-baud-rates-above-1Mbaud.patch \
	file://3.2.3/0089-mach-ux500-no-MMC_CAP_SD_HIGHSPEED-on-Snowball.patch \
	file://3.2.3/0090-Linux-3.2.3.patch \
	file://3.2.4/0001-Revert-ASoC-Mark-WM5100-register-map-cache-only-when.patch \
	file://3.2.4/0002-Revert-ASoC-Don-t-go-through-cache-when-applying-WM5.patch \
	file://3.2.4/0003-Linux-3.2.4.patch \
	file://3.2.5/0001-PCI-Rework-ASPM-disable-code.patch \
	file://3.2.5/0002-Linux-3.2.5.patch \
	file://3.2.6/0001-readahead-fix-pipeline-break-caused-by-block-plug.patch \
	file://3.2.6/0002-ALSA-hda-Fix-the-logic-to-detect-VIA-analog-low-curr.patch \
	file://3.2.6/0003-ALSA-HDA-Remove-quirk-for-Asus-N53Jq.patch \
	file://3.2.6/0004-ALSA-hda-Apply-0x0f-VREF-fix-to-all-ASUS-laptops-wit.patch \
	file://3.2.6/0005-ALSA-hda-Fix-calling-cs_automic-twice-for-Cirrus-cod.patch \
	file://3.2.6/0006-ALSA-hda-Allow-analog-low-current-mode-when-dynamic-.patch \
	file://3.2.6/0007-ALSA-HDA-Fix-duplicated-output-to-more-than-one-code.patch \
	file://3.2.6/0008-ALSA-hda-Disable-dynamic-power-control-for-VIA-as-de.patch \
	file://3.2.6/0009-ASoC-wm_hubs-Enable-line-out-VMID-buffer-for-single-.patch \
	file://3.2.6/0010-ASoC-wm_hubs-fix-wrong-bits-for-LINEOUT2-N-P-mixer.patch \
	file://3.2.6/0011-ARM-7306-1-vfp-flush-thread-hwstate-before-restoring.patch \
	file://3.2.6/0012-ARM-7307-1-vfp-fix-ptrace-regset-modification-race.patch \
	file://3.2.6/0013-ARM-7308-1-vfp-flush-thread-hwstate-before-copying-p.patch \
	file://3.2.6/0014-ARM-OMAP2-GPMC-fix-device-size-setup.patch \
	file://3.2.6/0015-drivers-tty-vt-vt_ioctl.c-fix-KDFONTOP-32bit-compati.patch \
	file://3.2.6/0016-proc-mem_release-should-check-mm-NULL.patch \
	file://3.2.6/0017-proc-unify-mem_read-and-mem_write.patch \
	file://3.2.6/0018-proc-make-sure-mem_open-doesn-t-pin-the-target-s-mem.patch \
	file://3.2.6/0019-firewire-ohci-add-reset-packet-quirk-for-SB-Audigy.patch \
	file://3.2.6/0020-firewire-ohci-disable-MSI-on-Ricoh-controllers.patch \
	file://3.2.6/0021-IB-mlx4-pass-SMP-vendor-specific-attribute-MADs-to-f.patch \
	file://3.2.6/0022-RDMA-core-Fix-kernel-panic-by-always-initializing-qp.patch \
	file://3.2.6/0023-kprobes-fix-a-memory-leak-in-function-pre_handler_kr.patch \
	file://3.2.6/0024-mtd-gpmi-nand-bugfix-reset-the-BCH-module-when-it-is.patch \
	file://3.2.6/0025-Revert-mtd-atmel_nand-optimize-read-write-buffer-fun.patch \
	file://3.2.6/0026-at_hdmac-bugfix-for-enabling-channel-irq.patch \
	file://3.2.6/0027-mm-filemap_xip.c-fix-race-condition-in-xip_file_faul.patch \
	file://3.2.6/0028-mm-compaction-check-pfn_valid-when-entering-a-new-MA.patch \
	file://3.2.6/0029-PM-Hibernate-Fix-s2disk-regression-related-to-freezi.patch \
	file://3.2.6/0030-PM-QoS-CPU-C-state-breakage-with-PM-Qos-change.patch \
	file://3.2.6/0031-drm-radeon-Set-DESKTOP_HEIGHT-register-to-the-frameb.patch \
	file://3.2.6/0032-drm-nouveau-gem-fix-fence_sync-race-oops.patch \
	file://3.2.6/0033-drm-radeon-kms-disable-output-polling-when-suspended.patch \
	file://3.2.6/0034-drm-radeon-kms-fix-TRAVIS-panel-setup.patch \
	file://3.2.6/0035-sched-rt-Fix-task-stack-corruption-under-__ARCH_WANT.patch \
	file://3.2.6/0036-PM-Hibernate-Thaw-processes-in-SNAPSHOT_CREATE_IMAGE.patch \
	file://3.2.6/0037-PM-Hibernate-Thaw-kernel-threads-in-SNAPSHOT_CREATE_.patch \
	file://3.2.6/0038-8139cp-fix-missing-napi_gro_flush.patch \
	file://3.2.6/0039-udf-Mark-LVID-buffer-as-uptodate-before-marking-it-d.patch \
	file://3.2.6/0040-drm-i915-HDMI-hot-remove-notification-to-audio-drive.patch \
	file://3.2.6/0041-drm-i915-DisplayPort-hot-remove-notification-to-audi.patch \
	file://3.2.6/0042-drm-i915-check-ACTHD-of-all-rings.patch \
	file://3.2.6/0043-drm-i915-Fix-TV-Out-refresh-rate.patch \
	file://3.2.6/0044-drm-i915-handle-3rd-pipe.patch \
	file://3.2.6/0045-drm-i915-convert-force_wake_get-to-func-pointer-in-t.patch \
	file://3.2.6/0046-drm-i915-protect-force_wake_-get-put-with-the-gt_loc.patch \
	file://3.2.6/0047-eCryptfs-Infinite-loop-due-to-overflow-in-ecryptfs_w.patch \
	file://3.2.6/0048-hwmon-w83627ehf-Fix-number-of-fans-for-NCT6776F.patch \
	file://3.2.6/0049-cifs-Fix-oops-in-session-setup-code-for-null-user-mo.patch \
	file://3.2.6/0050-atmel_lcdfb-fix-usage-of-CONTRAST_CTR-in-suspend-res.patch \
	file://3.2.6/0051-lockdep-bug-Exclude-TAINT_FIRMWARE_WORKAROUND-from-d.patch \
	file://3.2.6/0052-lockdep-bug-Exclude-TAINT_OOT_MODULE-from-disabling-.patch \
	file://3.2.6/0053-iscsi-target-Fix-reject-release-handling-in-iscsit_f.patch \
	file://3.2.6/0054-iscsi-target-Fix-double-list_add-with-iscsit_alloc_b.patch \
	file://3.2.6/0055-iscsi-target-Fix-discovery-with-INADDR_ANY-and-IN6AD.patch \
	file://3.2.6/0056-ASoC-wm_hubs-Fix-routing-of-input-PGAs-to-line-outpu.patch \
	file://3.2.6/0057-ASoC-wm_hubs-Correct-line-input-to-line-output-2-pat.patch \
	file://3.2.6/0058-ASoC-wm8962-Fix-word-length-configuration.patch \
	file://3.2.6/0059-ASoC-wm8994-Enabling-VMID-should-take-a-runtime-PM-r.patch \
	file://3.2.6/0060-ASoC-wm8994-Fix-typo-in-VMID-ramp-setting.patch \
	file://3.2.6/0061-pcmcia-fix-socket-refcount-decrementing-on-each-resu.patch \
	file://3.2.6/0062-ALSA-oxygen-virtuoso-fix-exchanged-L-R-volumes-of-au.patch \
	file://3.2.6/0063-iommu-amd-Work-around-broken-IVRS-tables.patch \
	file://3.2.6/0064-iommu-msm-Fix-error-handling-in-msm_iommu_unmap.patch \
	file://3.2.6/0065-mm-compaction-check-for-overlapping-nodes-during-iso.patch \
	file://3.2.6/0066-mm-fix-UP-THP-spin_is_locked-BUGs.patch \
	file://3.2.6/0067-target-Use-correct-preempted-registration-sense-code.patch \
	file://3.2.6/0068-target-Allow-PERSISTENT-RESERVE-IN-for-non-reservati.patch \
	file://3.2.6/0069-target-Correct-sense-key-for-INVALID-FIELD-IN-PARAME.patch \
	file://3.2.6/0070-target-Add-workaround-for-zero-length-control-CDB-ha.patch \
	file://3.2.6/0071-target-Return-correct-ASC-for-unimplemented-VPD-page.patch \
	file://3.2.6/0072-target-Fail-INQUIRY-commands-with-EVPD-0-but-PAGE-CO.patch \
	file://3.2.6/0073-Staging-asus_oled-fix-image-processing.patch \
	file://3.2.6/0074-Staging-asus_oled-fix-NULL-ptr-crash-on-unloading.patch \
	file://3.2.6/0075-staging-r8712u-Add-new-Sitecom-UsB-ID.patch \
	file://3.2.6/0076-staging-r8712u-Use-asynchronous-firmware-loading.patch \
	file://3.2.6/0077-usb-ch9.h-usb_endpoint_maxp-uses-__le16_to_cpu.patch \
	file://3.2.6/0078-usb-gadget-zero-fix-bug-in-loopback-autoresume-handl.patch \
	file://3.2.6/0079-usb-Skip-PCI-USB-quirk-handling-for-Netlogic-XLP.patch \
	file://3.2.6/0080-USB-usbserial-add-new-PID-number-0xa951-to-the-ftdi-.patch \
	file://3.2.6/0081-USB-add-new-zte-3g-dongle-s-pid-to-option.c.patch \
	file://3.2.6/0082-zcache-Set-SWIZ_BITS-to-8-to-reduce-tmem-bucket-lock.patch \
	file://3.2.6/0083-zcache-fix-deadlock-condition.patch \
	file://3.2.6/0084-mmc-cb710-core-Add-missing-spin_lock_init-for-irq_lo.patch \
	file://3.2.6/0085-powernow-k8-Avoid-Pstate-MSR-accesses-on-systems-sup.patch \
	file://3.2.6/0086-powernow-k8-Fix-indexing-issue.patch \
	file://3.2.6/0087-Linux-3.2.6.patch \
	file://3.2.7/0001-ixgbe-fix-vf-lookup.patch \
	file://3.2.7/0002-igb-fix-vf-lookup.patch \
	file://3.2.7/0003-perf-evsel-Fix-an-issue-where-perf-report-fails-to-s.patch \
	file://3.2.7/0004-perf-tools-Fix-perf-stack-to-non-executable-on-x86_6.patch \
	file://3.2.7/0005-drm-i915-Force-explicit-bpp-selection-for-intel_dp_l.patch \
	file://3.2.7/0006-drm-i915-no-lvds-quirk-for-AOpen-MP45.patch \
	file://3.2.7/0007-ath9k-Fix-kernel-panic-during-driver-initilization.patch \
	file://3.2.7/0008-ath9k-fix-a-WEP-crypto-related-regression.patch \
	file://3.2.7/0009-ath9k_hw-fix-a-RTS-CTS-timeout-regression.patch \
	file://3.2.7/0010-hwmon-f75375s-Fix-bit-shifting-in-f75375_write16.patch \
	file://3.2.7/0011-net-enable-TC35815-for-MIPS-again.patch \
	file://3.2.7/0012-lib-proportion-lower-PROP_MAX_SHIFT-to-32-on-64-bit-.patch \
	file://3.2.7/0013-relay-prevent-integer-overflow-in-relay_open.patch \
	file://3.2.7/0014-mac80211-timeout-a-single-frame-in-the-rx-reorder-bu.patch \
	file://3.2.7/0015-writeback-fix-NULL-bdi-dev-in-trace-writeback_single.patch \
	file://3.2.7/0016-writeback-fix-dereferencing-NULL-bdi-dev-on-trace_wr.patch \
	file://3.2.7/0017-hwmon-f75375s-Fix-automatic-pwm-mode-setting-for-F75.patch \
	file://3.2.7/0018-cifs-request-oplock-when-doing-open-on-lookup.patch \
	file://3.2.7/0019-cifs-don-t-return-error-from-standard_receive3-after.patch \
	file://3.2.7/0020-crypto-sha512-Use-binary-and-instead-of-modulus.patch \
	file://3.2.7/0021-crypto-sha512-Avoid-stack-bloat-on-i386.patch \
	file://3.2.7/0022-backing-dev-fix-wakeup-timer-races-with-bdi_unregist.patch \
	file://3.2.7/0023-ALSA-intel8x0-Fix-default-inaudible-sound-on-Gateway.patch \
	file://3.2.7/0024-ALSA-hda-Fix-initialization-of-secondary-capture-sou.patch \
	file://3.2.7/0025-ALSA-hda-Fix-silent-speaker-output-on-Acer-Aspire-69.patch \
	file://3.2.7/0026-mmc-atmel-mci-save-and-restore-sdioirq-when-soft-res.patch \
	file://3.2.7/0027-mmc-dw_mmc-Fix-PIO-mode-with-support-of-highmem.patch \
	file://3.2.7/0028-xen-pvhvm-do-not-remap-pirqs-onto-evtchns-if-xen_hav.patch \
	file://3.2.7/0029-crypto-sha512-use-standard-ror64.patch \
	file://3.2.7/0030-Linux-3.2.7.patch \
	file://3.2.8/0001-i387-math_state_restore-isn-t-called-from-asm.patch \
	file://3.2.8/0002-i387-make-irq_fpu_usable-tests-more-robust.patch \
	file://3.2.8/0003-i387-fix-sense-of-sanity-check.patch \
	file://3.2.8/0004-i387-fix-x86-64-preemption-unsafe-user-stack-save-re.patch \
	file://3.2.8/0005-i387-move-TS_USEDFPU-clearing-out-of-__save_init_fpu.patch \
	file://3.2.8/0006-i387-don-t-ever-touch-TS_USEDFPU-directly-use-helper.patch \
	file://3.2.8/0007-i387-do-not-preload-FPU-state-at-task-switch-time.patch \
	file://3.2.8/0008-i387-move-AMD-K7-K8-fpu-fxsave-fxrstor-workaround-fr.patch \
	file://3.2.8/0009-i387-move-TS_USEDFPU-flag-from-thread_info-to-task_s.patch \
	file://3.2.8/0010-i387-re-introduce-FPU-state-preloading-at-context-sw.patch \
	file://3.2.8/0011-Linux-3.2.8.patch \
	file://3.2.9/0001-Security-tomoyo-add-.gitignore-file.patch \
	file://3.2.9/0002-powerpc-perf-power_pmu_start-restores-incorrect-valu.patch \
	file://3.2.9/0003-ARM-at91-USB-AT91-gadget-registration-for-module.patch \
	file://3.2.9/0004-drm-radeon-kms-fix-MSI-re-arm-on-rv370.patch \
	file://3.2.9/0005-PCI-workaround-hard-wired-bus-number-V2.patch \
	file://3.2.9/0006-mac80211-Fix-a-rwlock-bad-magic-bug.patch \
	file://3.2.9/0007-ipheth-Add-iPhone-4S.patch \
	file://3.2.9/0008-regmap-Fix-cache-defaults-initialization-from-raw-ca.patch \
	file://3.2.9/0009-eCryptfs-Copy-up-lower-inode-attrs-after-setting-low.patch \
	file://3.2.9/0010-S390-correct-ktime-to-tod-clock-comparator-conversio.patch \
	file://3.2.9/0011-vfs-fix-d_inode_lookup-dentry-ref-leak.patch \
	file://3.2.9/0012-ARM-7326-2-PL330-fix-null-pointer-dereference-in-pl3.patch \
	file://3.2.9/0013-ALSA-hda-Fix-redundant-jack-creations-for-cx5051.patch \
	file://3.2.9/0014-mmc-core-check-for-zero-length-ioctl-data.patch \
	file://3.2.9/0015-NFSv4-Fix-an-Oops-in-the-NFSv4-getacl-code.patch \
	file://3.2.9/0016-NFSv4-Ensure-we-throw-out-bad-delegation-stateids-on.patch \
	file://3.2.9/0017-NFSv4-fix-server_scope-memory-leak.patch \
	file://3.2.9/0018-ARM-7321-1-cache-v7-Disable-preemption-when-reading-.patch \
	file://3.2.9/0019-ARM-7325-1-fix-v7-boot-with-lockdep-enabled.patch \
	file://3.2.9/0020-3c59x-shorten-timer-period-for-slave-devices.patch \
	file://3.2.9/0021-net-Don-t-proxy-arp-respond-if-iif-rt-dst.dev-if-pri.patch \
	file://3.2.9/0022-netpoll-netpoll_poll_dev-should-access-dev-flags.patch \
	file://3.2.9/0023-net_sched-Bug-in-netem-reordering.patch \
	file://3.2.9/0024-veth-Enforce-minimum-size-of-VETH_INFO_PEER.patch \
	file://3.2.9/0025-via-velocity-S3-resume-fix.patch \
	file://3.2.9/0026-ipv4-reset-flowi-parameters-on-route-connect.patch \
	file://3.2.9/0027-tcp_v4_send_reset-binding-oif-to-iif-in-no-sock-case.patch \
	file://3.2.9/0028-ipv4-Fix-wrong-order-of-ip_rt_get_source-and-update-.patch \
	file://3.2.9/0029-net-Make-qdisc_skb_cb-upper-size-bound-explicit.patch \
	file://3.2.9/0030-IPoIB-Stop-lying-about-hard_header_len-and-use-skb-c.patch \
	file://3.2.9/0031-gro-more-generic-L2-header-check.patch \
	file://3.2.9/0032-tcp-allow-tcp_sacktag_one-to-tag-ranges-not-aligned-.patch \
	file://3.2.9/0033-tcp-fix-range-tcp_shifted_skb-passes-to-tcp_sacktag_.patch \
	file://3.2.9/0034-tcp-fix-tcp_shifted_skb-adjustment-of-lost_cnt_hint-.patch \
	file://3.2.9/0035-USB-Added-Kamstrup-VID-PIDs-to-cp210x-serial-driver.patch \
	file://3.2.9/0036-USB-option-cleanup-zte-3g-dongle-s-pid-in-option.c.patch \
	file://3.2.9/0037-USB-Serial-ti_usb_3410_5052-Add-Abbot-Diabetes-Care-.patch \
	file://3.2.9/0038-USB-Remove-duplicate-USB-3.0-hub-feature-defines.patch \
	file://3.2.9/0039-USB-Fix-handoff-when-BIOS-disables-host-PCI-device.patch \
	file://3.2.9/0040-xhci-Fix-oops-caused-by-more-USB2-ports-than-USB3-po.patch \
	file://3.2.9/0041-xhci-Fix-encoding-for-HS-bulk-control-NAK-rate.patch \
	file://3.2.9/0042-USB-Don-t-fail-USB3-probe-on-missing-legacy-PCI-IRQ.patch \
	file://3.2.9/0043-USB-Set-hub-depth-after-USB3-hub-reset.patch \
	file://3.2.9/0044-usb-storage-fix-freezing-of-the-scanning-thread.patch \
	file://3.2.9/0045-target-Allow-control-CDBs-with-data-1-page.patch \
	file://3.2.9/0046-ASoC-wm8962-Fix-sidetone-enumeration-texts.patch \
	file://3.2.9/0047-ALSA-hda-realtek-Fix-overflow-of-vol-sw-check-bitmap.patch \
	file://3.2.9/0048-ALSA-hda-realtek-Fix-surround-output-regression-on-A.patch \
	file://3.2.9/0049-NOMMU-Lock-i_mmap_mutex-for-access-to-the-VMA-prio-l.patch \
	file://3.2.9/0050-hwmon-max6639-Fix-FAN_FROM_REG-calculation.patch \
	file://3.2.9/0051-hwmon-max6639-Fix-PPR-register-initialization-to-set.patch \
	file://3.2.9/0052-hwmon-ads1015-Fix-file-leak-in-probe-function.patch \
	file://3.2.9/0053-ARM-omap-fix-oops-in-drivers-video-omap2-dss-dpi.c.patch \
	file://3.2.9/0054-x86-amd-Fix-L1i-and-L2-cache-sharing-information-for.patch \
	file://3.2.9/0055-ath9k-stop-on-rates-with-idx-1-in-ath9k-rate-control.patch \
	file://3.2.9/0056-genirq-Unmask-oneshot-irqs-when-thread-was-not-woken.patch \
	file://3.2.9/0057-genirq-Handle-pending-irqs-in-irq_startup.patch \
	file://3.2.9/0058-scsi_scan-Fix-Poison-overwritten-warning-caused-by-u.patch \
	file://3.2.9/0059-scsi_pm-Fix-bug-in-the-SCSI-power-management-handler.patch \
	file://3.2.9/0060-ipvs-fix-matching-of-fwmark-templates-during-schedul.patch \
	file://3.2.9/0061-jme-Fix-FIFO-flush-issue.patch \
	file://3.2.9/0062-davinci_emac-Do-not-free-all-rx-dma-descriptors-duri.patch \
	file://3.2.9/0063-builddeb-Don-t-create-files-in-tmp-with-predictable-.patch \
	file://3.2.9/0064-can-sja1000-fix-isr-hang-when-hw-is-unplugged-under-.patch \
	file://3.2.9/0065-hdpvr-fix-race-conditon-during-start-of-streaming.patch \
	file://3.2.9/0066-imon-don-t-wedge-hardware-after-early-callbacks.patch \
	file://3.2.9/0067-hwmon-f75375s-Fix-register-write-order-when-setting-.patch \
	file://3.2.9/0068-epoll-introduce-POLLFREE-to-flush-signalfd_wqh-befor.patch \
	file://3.2.9/0069-epoll-ep_unregister_pollwait-can-use-the-freed-pwq-w.patch \
	file://3.2.9/0070-epoll-limit-paths.patch \
	file://3.2.9/0071-cdrom-use-copy_to_user-without-the-underscores.patch \
	file://3.2.9/0072-Linux-3.2.9.patch \
	file://3.2.10/0001-autofs-work-around-unhappy-compat-problem-on-x86-64.patch \
	file://3.2.10/0002-Fix-autofs-compile-without-CONFIG_COMPAT.patch \
	file://3.2.10/0003-compat-fix-compile-breakage-on-s390.patch \
	file://3.2.10/0004-drm-i915-Prevent-a-machine-hang-by-checking-crtc-act.patch \
	file://3.2.10/0005-ARM-LPC32xx-serial.c-HW-bug-workaround.patch \
	file://3.2.10/0006-ARM-LPC32xx-serial.c-Fixed-loop-limit.patch \
	file://3.2.10/0007-ARM-LPC32xx-irq.c-Clear-latched-event.patch \
	file://3.2.10/0008-ARM-LPC32xx-Fix-interrupt-controller-init.patch \
	file://3.2.10/0009-ARM-LPC32xx-Fix-irq-on-GPI_28.patch \
	file://3.2.10/0010-watchdog-hpwdt-clean-up-set_memory_x-call-for-32-bit.patch \
	file://3.2.10/0011-i2c-mxs-only-flag-completion-when-queue-is-completel.patch \
	file://3.2.10/0012-regulator-fix-the-ldo-configure-according-to-88pm860.patch \
	file://3.2.10/0013-S390-KEYS-Enable-the-compat-keyctl-wrapper-on-s390x.patch \
	file://3.2.10/0014-perf-x86-kvm-Fix-Host-Only-Guest-Only-counting-with-.patch \
	file://3.2.10/0015-ALSA-hda-realtek-Fix-resume-of-multiple-input-source.patch \
	file://3.2.10/0016-ALSA-hda-Add-a-fake-mute-feature.patch \
	file://3.2.10/0017-ALSA-hda-Always-set-HP-pin-in-unsol-handler-for-STAC.patch \
	file://3.2.10/0018-regset-Prevent-null-pointer-reference-on-readonly-re.patch \
	file://3.2.10/0019-regset-Return-EFAULT-not-EIO-on-host-side-memory-fau.patch \
	file://3.2.10/0020-mfd-Fix-ACPI-conflict-check.patch \
	file://3.2.10/0021-mfd-Test-for-jack-detection-when-deciding-if-wm8994-.patch \
	file://3.2.10/0022-genirq-Clear-action-thread_mask-if-IRQ_ONESHOT-is-no.patch \
	file://3.2.10/0023-ARM-S3C24XX-DMA-resume-regression-fix.patch \
	file://3.2.10/0024-Move-Logitech-Harmony-900-from-cdc_ether-to-zaurus.patch \
	file://3.2.10/0025-alpha-fix-32-64-bit-bug-in-futex-support.patch \
	file://3.2.10/0026-mmc-atmel-mci-don-t-use-dma-features-when-using-DMA-.patch \
	file://3.2.10/0027-mmc-sdhci-esdhc-imx-fix-for-mmc-cards-on-i.MX5.patch \
	file://3.2.10/0028-aio-wake-up-waiters-when-freeing-unused-kiocbs.patch \
	file://3.2.10/0029-mm-memcg-Correct-unregistring-of-events-attached-to-.patch \
	file://3.2.10/0030-NOMMU-Don-t-need-to-clear-vm_mm-when-deleting-a-VMA.patch \
	file://3.2.10/0031-cifs-fix-dentry-refcount-leak-when-opening-a-FIFO-on.patch \
	file://3.2.10/0032-mac80211-zero-initialize-count-field-in-ieee80211_tx.patch \
	file://3.2.10/0033-ath9k_hw-prevent-writes-to-const-data-on-AR9160.patch \
	file://3.2.10/0034-kprobes-return-proper-error-code-from-register_kprob.patch \
	file://3.2.10/0035-mm-thp-fix-BUG-on-mm-nr_ptes.patch \
	file://3.2.10/0036-iwlwifi-fix-key-removal.patch \
	file://3.2.10/0037-tty-powerpc-early-udbg-consoles-can-t-be-modules.patch \
	file://3.2.10/0038-S390-qdio-fix-handler-function-arguments-for-zfcp-da.patch \
	file://3.2.10/0039-rapidio-tsi721-fix-queue-wrapping-bug-in-inbound-doo.patch \
	file://3.2.10/0040-HID-usbhid-Add-NOGET-quirk-for-the-AIREN-Slim-keyboa.patch \
	file://3.2.10/0041-crypto-mv_cesa-fix-final-callback-not-ignoring-input.patch \
	file://3.2.10/0042-osd_uld-Bump-MAX_OSD_DEVICES-from-64-to-1-048-576.patch \
	file://3.2.10/0043-viafb-select-HW-scaling-on-VX900-for-IGA2.patch \
	file://3.2.10/0044-viafb-fix-IGA1-modesetting-on-VX900.patch \
	file://3.2.10/0045-ASoC-dapm-Check-for-bias-level-when-powering-down.patch \
	file://3.2.10/0046-ASoC-i.MX-SSI-Fix-DSP_A-format.patch \
	file://3.2.10/0047-bsg-fix-sysfs-link-remove-warning.patch \
	file://3.2.10/0048-avr32-select-generic-atomic64_t-support.patch \
	file://3.2.10/0049-ACPI-PM-Do-not-save-restore-NVS-on-Asus-K54C-K54HR.patch \
	file://3.2.10/0050-rtl8192cu-Add-new-device-IDs.patch \
	file://3.2.10/0051-drm-i915-gen7-implement-rczunit-workaround.patch \
	file://3.2.10/0052-drm-i915-gen7-Implement-an-L3-caching-workaround.patch \
	file://3.2.10/0053-drm-i915-gen7-work-around-a-system-hang-on-IVB.patch \
	file://3.2.10/0054-drm-i915-gen7-Disable-the-RHWO-optimization-as-it-ca.patch \
	file://3.2.10/0055-drm-i915-fix-ELD-writing-for-SandyBridge.patch \
	file://3.2.10/0056-ARM-orion-Fix-USB-phy-for-orion5x.patch \
	file://3.2.10/0057-ARM-orion-Fix-Orion5x-GPIO-regression-from-MPP-clean.patch \
	file://3.2.10/0058-OMAP-4430SDP-Panda-use-gpio_free_array-to-free-HDMI-.patch \
	file://3.2.10/0059-OMAP-4430SDP-Panda-rename-HPD-GPIO-to-CT_CP_HPD.patch \
	file://3.2.10/0060-OMAPDSS-remove-wrong-HDMI-HPD-muxing.patch \
	file://3.2.10/0061-OMAP-4430SDP-Panda-setup-HDMI-GPIO-muxes.patch \
	file://3.2.10/0062-OMAP-4430SDP-Panda-add-HDMI-HPD-gpio.patch \
	file://3.2.10/0063-OMAPDSS-HDMI-PHY-burnout-fix.patch \
	file://3.2.10/0064-OMAPDSS-HDMI-hot-plug-detect-fix.patch \
	file://3.2.10/0065-ARM-7345-1-errata-update-workaround-for-A9-erratum-7.patch \
	file://3.2.10/0066-ARM-7354-1-perf-limit-sample_period-to-half-max_peri.patch \
	file://3.2.10/0067-ARM-7355-1-perf-clear-overflow-flag-when-disabling-c.patch \
	file://3.2.10/0068-ARM-7356-1-perf-check-that-we-have-an-event-in-the-P.patch \
	file://3.2.10/0069-ARM-7357-1-perf-fix-overflow-handling-for-xscale2-PM.patch \
	file://3.2.10/0070-media-staging-lirc_serial-Fix-init-exit-order.patch \
	file://3.2.10/0071-media-staging-lirc_serial-Free-resources-on-failure-.patch \
	file://3.2.10/0072-media-staging-lirc_serial-Fix-deadlock-on-resume-fai.patch \
	file://3.2.10/0073-media-staging-lirc_serial-Do-not-assume-error-codes-.patch \
	file://3.2.10/0074-Input-ALPS-fix-touchpad-detection-when-buttons-are-p.patch \
	file://3.2.10/0075-hwmon-pmbus_core-Fix-maximum-number-of-POUT-alarm-at.patch \
	file://3.2.10/0076-hwmon-jc42-Add-support-for-ST-Microelectronics-STTS2.patch \
	file://3.2.10/0077-hwmon-jc42-Add-support-for-AT30TS00-TS3000GB2-TSE200.patch \
	file://3.2.10/0078-hwmon-zl6100-Maintain-delay-parameter-in-driver-inst.patch \
	file://3.2.10/0079-carl9170-Fix-memory-accounting-when-sta-is-in-power-.patch \
	file://3.2.10/0080-carl9170-fix-frame-delivery-if-sta-is-in-powersave-m.patch \
	file://3.2.10/0081-drm-radeon-kms-set-SX_MISC-in-the-r6xx-blit-code-v2.patch \
	file://3.2.10/0082-net-usbnet-avoid-recursive-locking-in-usbnet_stop.patch \
	file://3.2.10/0083-x86-amd-iommu_set_device_table-must-not-be-__init.patch \
	file://3.2.10/0084-dm-ioctl-do-not-leak-argv-if-target-message-only-con.patch \
	file://3.2.10/0085-dm-io-fix-discard-support.patch \
	file://3.2.10/0086-dm-flakey-fix-crash-on-read-when-corrupt_bio_byte-no.patch \
	file://3.2.10/0087-dm-thin-metadata-remove-incorrect-close_device-on-cr.patch \
	file://3.2.10/0088-dm-thin-metadata-unlock-superblock-in-init_pmd-error.patch \
	file://3.2.10/0089-dm-thin-metadata-decrement-counter-after-removing-ma.patch \
	file://3.2.10/0090-dm-raid-set-MD_CHANGE_DEVS-when-rebuilding.patch \
	file://3.2.10/0091-dm-raid-fix-flush-support.patch \
	file://3.2.10/0092-cs5535-mfgpt-don-t-call-__init-function-from-__devin.patch \
	file://3.2.10/0093-mfd-Fix-cs5535-section-mismatch.patch \
	file://3.2.10/0094-spi-topcliff-pch-rename-pch_spi_pcidev-to-pch_spi_pc.patch \
	file://3.2.10/0095-Linux-3.2.10.patch \
	file://3.2.11/0001-Revert-mfd-Test-for-jack-detection-when-deciding-if-.patch \
	file://3.2.11/0002-Linux-3.2.11.patch \
	file://3.2.12/0001-ASoC-neo1973-fix-neo1973-wm8753-initialization.patch \
	file://3.2.12/0002-ALSA-hda-realtek-Apply-the-coef-setup-only-to-ALC269.patch \
	file://3.2.12/0003-aio-fix-io_setup-io_destroy-race.patch \
	file://3.2.12/0004-aio-fix-the-too-late-munmap-race.patch \
	file://3.2.12/0005-x86-Derandom-delay_tsc-for-64-bit.patch \
	file://3.2.12/0006-PCI-ignore-pre-1.1-ASPM-quirking-when-ASPM-is-disabl.patch \
	file://3.2.12/0007-omap3isp-ccdc-Fix-crash-in-HS-VS-interrupt-handler.patch \
	file://3.2.12/0008-rt2x00-fix-random-stalls.patch \
	file://3.2.12/0009-perf-x86-Fix-local-vs-remote-memory-events-for-NHM-W.patch \
	file://3.2.12/0010-CIFS-Do-not-kmalloc-under-the-flocks-spinlock.patch \
	file://3.2.12/0011-vfs-fix-return-value-from-do_last.patch \
	file://3.2.12/0012-vfs-fix-double-put-after-complete_walk.patch \
	file://3.2.12/0013-acer-wmi-No-wifi-rfkill-on-Lenovo-machines.patch \
	file://3.2.12/0014-atl1c-dont-use-highprio-tx-queue.patch \
	file://3.2.12/0015-neighbour-Fixed-race-condition-at-tbl-nht.patch \
	file://3.2.12/0016-ipsec-be-careful-of-non-existing-mac-headers.patch \
	file://3.2.12/0017-ppp-fix-ppp_mp_reconstruct-bad-seq-errors.patch \
	file://3.2.12/0018-sfc-Fix-assignment-of-ip_summed-for-pre-allocated-sk.patch \
	file://3.2.12/0019-tcp-fix-false-reordering-signal-in-tcp_shifted_skb.patch \
	file://3.2.12/0020-vmxnet3-Fix-transport-header-size.patch \
	file://3.2.12/0021-packetengines-fix-config-default.patch \
	file://3.2.12/0022-r8169-corrupted-IP-fragments-fix-for-large-mtu.patch \
	file://3.2.12/0023-tcp-don-t-fragment-SACKed-skbs-in-tcp_mark_head_lost.patch \
	file://3.2.12/0024-bridge-check-return-value-of-ipv6_dev_get_saddr.patch \
	file://3.2.12/0025-tcp-fix-tcp_shift_skb_data-to-not-shift-SACKed-data-.patch \
	file://3.2.12/0026-IPv6-Fix-not-join-all-router-mcast-group-when-forwar.patch \
	file://3.2.12/0027-usb-asix-Patch-for-Sitecom-LN-031.patch \
	file://3.2.12/0028-regulator-Fix-setting-selector-in-tps6524x-set_volta.patch \
	file://3.2.12/0029-block-Fix-NULL-pointer-dereference-in-sd_revalidate_.patch \
	file://3.2.12/0030-block-sx8-fix-pointer-math-issue-getting-fw-version.patch \
	file://3.2.12/0031-block-fix-__blkdev_get-and-add_disk-race-condition.patch \
	file://3.2.12/0032-Block-use-a-freezable-workqueue-for-disk-event-polli.patch \
	file://3.2.12/0033-sparc32-Add-Av8-to-assembler-command-line.patch \
	file://3.2.12/0034-hwmon-w83627ehf-Fix-writing-into-fan_stop_time-for-N.patch \
	file://3.2.12/0035-hwmon-w83627ehf-Fix-memory-leak-in-probe-function.patch \
	file://3.2.12/0036-hwmon-w83627ehf-Fix-temp2-source-for-W83627UHG.patch \
	file://3.2.12/0037-rapidio-tsi721-fix-bug-in-register-offset-definition.patch \
	file://3.2.12/0038-i2c-algo-bit-Fix-spurious-SCL-timeouts-under-heavy-l.patch \
	file://3.2.12/0039-iscsi-target-Fix-reservation-conflict-EBUSY-response.patch \
	file://3.2.12/0040-target-Fix-compatible-reservation-handling-CRH-1-wit.patch \
	file://3.2.12/0041-hwmon-zl6100-Enable-interval-between-chip-accesses-f.patch \
	file://3.2.12/0042-Linux-3.2.12.patch \
	file://3.2.13/0001-nilfs2-fix-NULL-pointer-dereference-in-nilfs_load_su.patch \
	file://3.2.13/0002-afs-Read-of-file-returns-EBADMSG.patch \
	file://3.2.13/0003-afs-Remote-abort-can-cause-BUG-in-rxrpc-code.patch \
	file://3.2.13/0004-perf-tools-Incorrect-use-of-snprintf-results-in-SEGV.patch \
	file://3.2.13/0005-perf-tools-Use-scnprintf-where-applicable.patch \
	file://3.2.13/0006-tcp-fix-syncookie-regression.patch \
	file://3.2.13/0007-ipv6-Don-t-dev_hold-dev-in-ip6_mc_find_dev_rcu.patch \
	file://3.2.13/0008-iwl3945-fix-possible-il-txq-NULL-pointer-dereference.patch \
	file://3.2.13/0009-powerpc-pmac-Fix-SMP-kernels-on-pre-core99-UP-machin.patch \
	file://3.2.13/0010-Linux-3.2.13.patch \
	file://3.2.14/0001-USB-option-Add-MediaTek-MT6276M-modem-app-interfaces.patch \
	file://3.2.14/0002-USB-option-driver-adding-support-for-Telit-CC864-SIN.patch \
	file://3.2.14/0003-USB-option-make-interface-blacklist-work-again.patch \
	file://3.2.14/0004-USB-option-add-ZTE-MF820D.patch \
	file://3.2.14/0005-staging-zcache-avoid-AB-BA-deadlock-condition.patch \
	file://3.2.14/0006-USB-ftdi_sio-fix-problem-when-the-manufacture-is-a-N.patch \
	file://3.2.14/0007-USB-ftdi_sio-add-support-for-BeagleBone-rev-A5.patch \
	file://3.2.14/0008-USB-Microchip-VID-mislabeled-as-Hornby-VID-in-ftdi_s.patch \
	file://3.2.14/0009-USB-ftdi_sio-new-PID-Distortec-JTAG-lock-pick.patch \
	file://3.2.14/0010-USB-ftdi_sio-add-support-for-FT-X-series-devices.patch \
	file://3.2.14/0011-USB-ftdi_sio-new-PID-LUMEL-PD12.patch \
	file://3.2.14/0012-powerpc-usb-fix-bug-of-kernel-hang-when-initializing.patch \
	file://3.2.14/0013-staging-r8712u-Add-missing-initialization-and-remove.patch \
	file://3.2.14/0014-staging-r8712u-Fix-regression-introduced-by-commit-a.patch \
	file://3.2.14/0015-staging-r8712u-Fix-regression-in-signal-level-after-.patch \
	file://3.2.14/0016-usb-dwc3-fix-bogus-test-in-dwc3_gadget_start_isoc.patch \
	file://3.2.14/0017-usb-dwc3-use-proper-function-for-setting-endpoint-na.patch \
	file://3.2.14/0018-usb-gadgetfs-return-number-of-bytes-on-ep0-read-requ.patch \
	file://3.2.14/0019-USB-gadget-Make-g_hid-device-class-conform-to-spec.patch \
	file://3.2.14/0020-futex-Cover-all-PI-opcodes-with-cmpxchg-enabled-chec.patch \
	file://3.2.14/0021-sysfs-Fix-memory-leak-in-sysfs_sd_setsecdata.patch \
	file://3.2.14/0022-tty-moxa-fix-bit-test-in-moxa_start.patch \
	file://3.2.14/0023-TTY-Wrong-unicode-value-copied-in-con_set_unimap.patch \
	file://3.2.14/0024-USB-serial-fix-console-error-reporting.patch \
	file://3.2.14/0025-cdc-wdm-Fix-more-races-on-the-read-path.patch \
	file://3.2.14/0026-cdc-wdm-Don-t-clear-WDM_READ-unless-entire-read-buff.patch \
	file://3.2.14/0027-usb-fsl_udc_core-Fix-scheduling-while-atomic-dump-me.patch \
	file://3.2.14/0028-usb-Fix-build-error-due-to-dma_mask-is-not-at-pdev_a.patch \
	file://3.2.14/0029-USB-ums_realtek-do-not-use-stack-memory-for-DMA-in-_.patch \
	file://3.2.14/0030-USB-qcserial-add-several-new-serial-devices.patch \
	file://3.2.14/0031-USB-qcserial-don-t-grab-QMI-port-on-Gobi-1000-device.patch \
	file://3.2.14/0032-usb-serial-Add-support-for-the-Sealevel-SeaLINK-8-20.patch \
	file://3.2.14/0033-usb-cp210x-Update-to-support-CP2105-and-multiple-int.patch \
	file://3.2.14/0034-USB-serial-mos7840-Fixed-MCS7820-device-attach-probl.patch \
	file://3.2.14/0035-rt2x00-Add-support-for-D-Link-DWA-127-to-rt2800usb.patch \
	file://3.2.14/0036-rtlwifi-rtl8192c_common-rtl8192de-Check-for-allocati.patch \
	file://3.2.14/0037-rtlwifi-Handle-previous-allocation-failures-when-fre.patch \
	file://3.2.14/0038-rtlwifi-rtl8192c-Prevent-sleeping-from-invalid-conte.patch \
	file://3.2.14/0039-rtlwifi-rtl8192ce-Fix-loss-of-receive-performance.patch \
	file://3.2.14/0040-iwlwifi-always-monitor-for-stuck-queues.patch \
	file://3.2.14/0041-math-Introduce-div64_long.patch \
	file://3.2.14/0042-ntp-Fix-integer-overflow-when-setting-time.patch \
	file://3.2.14/0043-uevent-send-events-in-correct-order-according-to-seq.patch \
	file://3.2.14/0044-genirq-Fix-long-term-regression-in-genirq-irq_set_ir.patch \
	file://3.2.14/0045-genirq-Fix-incorrect-check-for-forced-IRQ-thread-han.patch \
	file://3.2.14/0046-rtc-Disable-the-alarm-in-the-hardware-v2.patch \
	file://3.2.14/0047-p54spi-Release-GPIO-lines-and-IRQ-on-error-in-p54spi.patch \
	file://3.2.14/0048-rtnetlink-Fix-VF-IFLA-policy.patch \
	file://3.2.14/0049-IB-iser-Post-initial-receive-buffers-before-sending-.patch \
	file://3.2.14/0050-ima-fix-Kconfig-dependencies.patch \
	file://3.2.14/0051-x86-ioapic-Add-register-level-checks-to-detect-bogus.patch \
	file://3.2.14/0052-mm-thp-fix-pmd_bad-triggering-in-code-paths-holding-.patch \
	file://3.2.14/0053-TPM-Zero-buffer-whole-after-copying-to-userspace.patch \
	file://3.2.14/0054-PM-Domains-Fix-handling-of-wakeup-devices-during-sys.patch \
	file://3.2.14/0055-bootmem-sparsemem-remove-limit-constraint-in-alloc_b.patch \
	file://3.2.14/0056-hugetlbfs-avoid-taking-i_mutex-from-hugetlbfs_read.patch \
	file://3.2.14/0057-ASoC-fsl-p1022ds-tell-the-WM8776-codec-driver-that-i.patch \
	file://3.2.14/0058-ASoC-pxa-ssp-atomically-set-stream-active-masks.patch \
	file://3.2.14/0059-tcm_loop-Set-residual-field-for-SCSI-commands.patch \
	file://3.2.14/0060-iscsi-target-Fix-iscsit_alloc_buffs-failure-cases.patch \
	file://3.2.14/0061-iscsi-target-Fix-dynamic-explict-NodeACL-pointer-ref.patch \
	file://3.2.14/0062-ALSA-hda-fix-printing-of-high-HDMI-sample-rates.patch \
	file://3.2.14/0063-usb-gadget-fix-a-section-mismatch-when-compiling-g_f.patch \
	file://3.2.14/0064-udlfb-remove-sysfs-framebuffer-device-with-USB-.disc.patch \
	file://3.2.14/0065-tcm_fc-Fix-fc_exch-memory-leak-in-ft_send_resp_statu.patch \
	file://3.2.14/0066-md-bitmap-ensure-to-load-bitmap-when-creating-via-sy.patch \
	file://3.2.14/0067-md-don-t-set-md-arrays-to-readonly-on-shutdown.patch \
	file://3.2.14/0068-md-raid1-raid10-avoid-deadlock-during-resync-recover.patch \
	file://3.2.14/0069-md-fix-clearing-of-the-changed-flags-for-the-bad-blo.patch \
	file://3.2.14/0070-drm-i915-Only-clear-the-GPU-domains-upon-a-successfu.patch \
	file://3.2.14/0071-drm-radeon-Restrict-offset-for-legacy-hardware-curso.patch \
	file://3.2.14/0072-drm-radeon-kms-fix-analog-load-detection-on-DVI-I-co.patch \
	file://3.2.14/0073-drm-radeon-kms-add-connector-quirk-for-Fujitsu-D3003.patch \
	file://3.2.14/0074-target-Don-t-set-WBUS16-or-SYNC-bits-in-INQUIRY-resp.patch \
	file://3.2.14/0075-target-fix-use-after-free-in-target_report_luns.patch \
	file://3.2.14/0076-target-prevent-NULL-pointer-dereference-in-target_re.patch \
	file://3.2.14/0077-target-Fix-16-bit-target-ports-for-SET-TARGET-PORT-G.patch \
	file://3.2.14/0078-Bluetooth-Add-AR30XX-device-ID-on-Asus-laptops.patch \
	file://3.2.14/0079-HID-add-extra-hotkeys-in-Asus-AIO-keyboards.patch \
	file://3.2.14/0080-HID-add-more-hotkeys-in-Asus-AIO-keyboards.patch \
	file://3.2.14/0081-pata_legacy-correctly-mask-recovery-field-for-HT6560.patch \
	file://3.2.14/0082-firewire-ohci-fix-too-early-completion-of-IR-multich.patch \
	file://3.2.14/0083-KVM-x86-extend-struct-x86_emulate_ops-with-get_cpuid.patch \
	file://3.2.14/0084-KVM-x86-fix-missing-checks-in-syscall-emulation.patch \
	file://3.2.14/0085-NFS-Properly-handle-the-case-where-the-delegation-is.patch \
	file://3.2.14/0086-NFSv4-Return-the-delegation-if-the-server-returns-NF.patch \
	file://3.2.14/0087-xfs-fix-inode-lookup-race.patch \
	file://3.2.14/0088-CIFS-Respect-negotiated-MaxMpxCount.patch \
	file://3.2.14/0089-cifs-fix-issue-mounting-of-DFS-ROOT-when-redirecting.patch \
	file://3.2.14/0090-CIFS-Fix-a-spurious-error-in-cifs_push_posix_locks.patch \
	file://3.2.14/0091-UBI-fix-error-handling-in-ubi_scan.patch \
	file://3.2.14/0092-UBI-fix-eraseblock-picking-criteria.patch \
	file://3.2.14/0093-SUNRPC-We-must-not-use-list_for_each_entry_safe-in-r.patch \
	file://3.2.14/0094-usbnet-increase-URB-reference-count-before-usb_unlin.patch \
	file://3.2.14/0095-usbnet-don-t-clear-urb-dev-in-tx_complete.patch \
	file://3.2.14/0096-e1000e-Avoid-wrong-check-on-TX-hang.patch \
	file://3.2.14/0097-x86-32-Fix-endless-loop-when-processing-signals-for-.patch \
	file://3.2.14/0098-proc-ns-use-d_set_d_op-API-to-set-dentry-ops-in-proc.patch \
	file://3.2.14/0099-iommu-amd-Fix-section-warning-for-prealloc_protectio.patch \
	file://3.2.14/0100-sysctl-protect-poll-in-entries-that-may-go-away.patch \
	file://3.2.14/0101-hwmon-fam15h_power-Correct-sign-extension-of-running.patch \
	file://3.2.14/0102-lgdt330x-fix-signedness-error-in-i2c_read_demod_byte.patch \
	file://3.2.14/0103-pvrusb2-fix-7MHz-8MHz-DVB-T-tuner-support-for-HVR190.patch \
	file://3.2.14/0104-mxl111sf-fix-error-on-stream-stop-in-mxl111sf_ep6_st.patch \
	file://3.2.14/0105-NFSv4-Rate-limit-the-state-manager-warning-messages.patch \
	file://3.2.14/0106-PM-Hibernate-Enable-usermodehelpers-in-hibernate-err.patch \
	file://3.2.14/0107-jbd2-clear-BH_Delay-BH_Unwritten-in-journal_unmap_bu.patch \
	file://3.2.14/0108-ext4-ignore-EXT4_INODE_JOURNAL_DATA-flag-with-delall.patch \
	file://3.2.14/0109-ext4-fix-race-between-unwritten-extent-conversion-an.patch \
	file://3.2.14/0110-ext4-fix-race-between-sync-and-completed-io-work.patch \
	file://3.2.14/0111-ext4-check-for-zero-length-extent.patch \
	file://3.2.14/0112-vfs-fix-d_ancestor-case-in-d_materialize_unique.patch \
	file://3.2.14/0113-ARM-tegra-select-required-CPU-and-L2-errata-options.patch \
	file://3.2.14/0114-udf-Fix-deadlock-in-udf_release_file.patch \
	file://3.2.14/0115-gpio-omap-fix-_set_gpio_irqenable-implementation.patch \
	file://3.2.14/0116-gpio-davinci-fix-oops-on-unbanked-gpio-irq-request.patch \
	file://3.2.14/0117-gpio-davinci-fix-enabling-unbanked-GPIO-IRQs.patch \
	file://3.2.14/0118-dm-crypt-fix-mempool-deadlock.patch \
	file://3.2.14/0119-dm-crypt-add-missing-error-handling.patch \
	file://3.2.14/0120-dm-exception-store-fix-init-error-path.patch \
	file://3.2.14/0121-dm-persistent-data-fix-btree-rebalancing-after-remov.patch \
	file://3.2.14/0122-dm-thin-fix-stacked-bi_next-usage.patch \
	file://3.2.14/0123-backlight-fix-typo-in-tosa_lcd.c.patch \
	file://3.2.14/0124-xfs-Fix-oops-on-IO-error-during-xlog_recover_process.patch \
	file://3.2.14/0125-slub-Do-not-hold-slub_lock-when-calling-sysfs_slab_a.patch \
	file://3.2.14/0126-NFSv4-Fix-two-infinite-loops-in-the-mount-code.patch \
	file://3.2.14/0127-NFSv4.1-Fix-layoutcommit-error-handling.patch \
	file://3.2.14/0128-module-Remove-module-size-limit.patch \
	file://3.2.14/0129-Bluetooth-btusb-fix-bInterval-for-high-super-speed-i.patch \
	file://3.2.14/0130-drm-i915-suspend-fbdev-device-around-suspend-hiberna.patch \
	file://3.2.14/0131-Fix-pppol2tp-getsockname.patch \
	file://3.2.14/0132-ipv6-fix-incorrent-ipv6-ipsec-packet-fragment.patch \
	file://3.2.14/0133-net-bpf_jit-fix-BPF_S_LDX_B_MSH-compilation.patch \
	file://3.2.14/0134-net-fix-a-potential-rcu_read_lock-imbalance-in-rt6_f.patch \
	file://3.2.14/0135-net-fix-napi_reuse_skb-skb-reserve.patch \
	file://3.2.14/0136-Remove-printk-from-rds_sendmsg.patch \
	file://3.2.14/0137-sky2-override-for-PCI-legacy-power-management.patch \
	file://3.2.14/0138-xfrm-Access-the-replay-notify-functions-via-the-regi.patch \
	file://3.2.14/0139-lockd-fix-arg-parsing-for-grace_period-and-timeout.patch \
	file://3.2.14/0140-x86-tsc-Skip-refined-tsc-calibration-on-systems-with.patch \
	file://3.2.14/0141-x86-tls-Off-by-one-limit-check.patch \
	file://3.2.14/0142-compat-use-sys_sendfile64-implementation-for-sendfil.patch \
	file://3.2.14/0143-rtc-Provide-flag-for-rtc-devices-that-don-t-support-.patch \
	file://3.2.14/0144-nfsd-don-t-allow-zero-length-strings-in-cache_parse.patch \
	file://3.2.14/0145-serial-sh-sci-fix-a-race-of-DMA-submit_tx-on-transfe.patch \
	file://3.2.14/0146-ASPM-Fix-pcie-devices-with-non-pcie-children.patch \
	file://3.2.14/0147-Linux-3.2.14.patch \
	file://beaglebone/0001-f_rndis-HACK-around-undefined-variables.patch \
	file://beaglebone/0002-da8xx-fb-add-DVI-support-for-beaglebone.patch \
	file://beaglebone/0003-beaglebone-rebase-everything-onto-3.2-WARNING-MEGAPA.patch \
	file://beaglebone/0004-more-beaglebone-merges.patch \
	file://beaglebone/0005-beaglebone-disable-tsadc.patch \
	file://beaglebone/0006-tscadc-Add-general-purpose-mode-untested-with-touchs.patch \
	file://beaglebone/0007-tscadc-Add-board-file-mfd-support-fix-warning.patch \
	file://beaglebone/0008-AM335X-init-tsc-bone-style-for-new-boards.patch \
	file://beaglebone/0009-tscadc-make-stepconfig-channel-configurable.patch \
	file://beaglebone/0010-tscadc-Trigger-through-sysfs.patch \
	file://beaglebone/0011-meta-ti-Remove-debug-messages-for-meta-ti.patch \
	file://beaglebone/0012-tscadc-switch-to-polling-instead-of-interrupts.patch \
	file://beaglebone/0013-beaglebone-fix-ADC-init.patch \
	file://beaglebone/0014-AM335x-MUX-add-ehrpwm1A.patch \
	file://beaglebone/0015-beaglebone-enable-PWM-for-lcd-backlight-backlight-is.patch \
	file://beaglebone/0016-omap_hsmmc-Set-dto-to-max-value-of-14-to-avoid-SD-Ca.patch \
	file://beaglebone/0017-beaglebone-set-default-brightness-to-50-for-pwm-back.patch \
	file://beaglebone/0018-st7735fb-WIP-framebuffer-driver-supporting-Adafruit-.patch \
	file://beaglebone/0019-beaglebone-use-P8_6-gpio1_3-as-w1-bus.patch \
	file://beaglebone/0020-beaglebone-add-support-for-Towertech-TT3201-CAN-cape.patch \
	file://beaglebone/0021-beaglebone-add-more-beagleboardtoys-cape-partnumbers.patch \
	file://beaglebone/0022-beaglebone-add-gpio-keys-for-lcd7-add-notes-for-miss.patch \
	file://beaglebone/0023-beaglebone-add-enter-key-for-lcd7-cape.patch \
	file://beaglebone/0024-beaglebone-add-gpio-keys-for-lcd.patch \
	file://beaglebone/0025-beaglebone-fix-direction-of-gpio-keys.patch \
	file://beaglebone/0026-beaglebone-fix-3.5-lcd-cape-support.patch \
	file://beaglebone/0027-beaglebone-decrease-PWM-frequency-to-old-value-LCD7-.patch \
	file://beaglebone/0028-beaglebone-fix-ehrpwm-backlight.patch \
	file://beaglebone/0029-beaglebone-also-report-cape-revision.patch \
	file://beaglebone/0030-beaglebone-don-t-compare-undefined-characters-it-mak.patch \
"


require rygel.inc

PR = "${INC_PR}.2"

LIC_FILES_CHKSUM = "file://COPYING;md5=3bf50002aefd002f49e7bb854063f7e7"

SRC_URI[archive.md5sum] = "ec05cb7217c6ac78ef276d6ab9a66b81"
SRC_URI[archive.sha256sum] = "828c080eba89abaea34b94b5ab53b2f89bf03937cb3838c787ee17846b6d7e02"

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

PRINC = "1"


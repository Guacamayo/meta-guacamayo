# prepend to file path so we get our own rc script
# (the rc script comments out the psplash section at the end)
FILESEXTRAPATHS_prepend := "${THISDIR}/sysvinit:"

PRINC = "1"

PR = "${INC_PR}.1"

require mx.inc
require mx-2.0.inc


LIC_FILES_CHKSUM = "file://COPYING.LIB;md5=243b725d71bb5df4a1e5920b344b86ad \
                    file://mx/mx-widget.c;beginline=8;endline=20;md5=13bba3c973a72414a701e1e87b5ee879"

require wayland.inc

PR = "${INCPR}.1"

SRC_URI[md5sum] = "23d6bcd500db9d1bb13e9b89722331dc"
SRC_URI[sha256sum] = "a38b915ce294efb3f45d3c66ea21f8424aea676656eca93af0edcc5d55a1efcb"


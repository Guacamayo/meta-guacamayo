require clutter-gst-2.0.inc
require clutter-gst-2.0-git.inc

PR = "${INCPR}.0"


require clutter-gst.inc
require clutter-gst-git.inc

DEPENDS    = "${STDDEPENDS} ${STDDEPENDS_EGL}"
CONFLICTS += "clutter-gst-1.10-x11"


require clutter-gst.inc
require clutter-gst-git.inc

DEPENDS    = "${STDDEPENDS} ${STDDEPENDS_X11}"
CONFLICTS += "clutter-gst-1.10-egl"


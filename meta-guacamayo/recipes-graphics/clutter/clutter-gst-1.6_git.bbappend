# Guacamayo-specific clutter-gst config

# make this machine-specific; we rely on the machine-specific cogl+clutter
# and don't want this shared across machines either
PACKAGE_ARCH = "${MACHINE_ARCH}"

PRINC = "1"

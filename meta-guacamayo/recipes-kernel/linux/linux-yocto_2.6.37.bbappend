FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-2.6.37:"

SRC_URI += "file://rt2800.cfg"

PR = "rgc1"
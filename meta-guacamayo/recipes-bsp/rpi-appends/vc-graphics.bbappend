
PRINC = "1"

COMPATIBLE_MACHINE = "raspberrypi"

PROVIDES += "virtual/libgles2"
RPROVIDES += "libgles2"


PRINC = "1"

module_autoload_snd-bcm2835 = "snd-bcm2835"

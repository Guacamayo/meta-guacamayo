
require rygel.inc

PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=3bf50002aefd002f49e7bb854063f7e7"

SRC_URI[archive.md5sum] = "b20e5b72fdece7b9f5f33d8fe6c24def"
SRC_URI[archive.sha256sum] = "90aaa180ad8c88a20b3050935a4b92221a96600765551fae7be60acc7ff3bd36"

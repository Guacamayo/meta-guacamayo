
require rygel.inc

PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=3bf50002aefd002f49e7bb854063f7e7"

SRC_URI[archive.md5sum] = "3dc5b29e658ed6eabf1d32b72adc545e"
SRC_URI[archive.sha256sum] = "5801ad08ef00aa3d8ce0c33643a04acecbb121be55cbea0a1bba02227def6ab5"

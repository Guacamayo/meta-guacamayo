
require rygel.inc

PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=3bf50002aefd002f49e7bb854063f7e7"

SRC_URI[archive.md5sum] = "ed3452bb0ca65459e8a14149f24d3a9c"
SRC_URI[archive.sha256sum] = "a0325afabb6a91cbe958864183adce80ad88bcaa0fc8f8ed3f434ee0d09935bf"

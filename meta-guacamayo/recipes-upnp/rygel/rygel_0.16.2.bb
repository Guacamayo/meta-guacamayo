
require rygel.inc

PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=3bf50002aefd002f49e7bb854063f7e7"

SRC_URI[archive.md5sum] = "a842f08bfb49ae3f859a2dad92761378"
SRC_URI[archive.sha256sum] = "eef36459d0dd5f25f56aa87c7f60e032a646ac66e69027d140b2c9e726f3ed6e"

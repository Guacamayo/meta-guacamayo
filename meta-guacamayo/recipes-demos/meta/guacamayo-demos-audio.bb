SUMMARY = "Demo Audio Meta Package"
DESCRIPTION = "Demo Audio Meta Package"
LICENSE = "MIT"

PR = "r0"

LIC_FILES_CHKSUM = "file://${GUACABASE}/meta-guacamayo/COPYING.MIT;md5=3da9cfbcb788c80a0384361b4de20420"

inherit allarch

ALLOW_EMPTY = "1"

RDEPENDS = "la-olla-express-panic"

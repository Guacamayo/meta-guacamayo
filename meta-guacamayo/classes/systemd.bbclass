# Dummy to pacify rpi-zram-service in meta-raspberrypi
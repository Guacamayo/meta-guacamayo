
PRINC = "2"

COMPATIBLE_MACHINE = "raspberrypi"

PROVIDES += "virtual/libgles2 libopenmaxil"
RPROVIDES += "libgles2 libopenmaxil"
